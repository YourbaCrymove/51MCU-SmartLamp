# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0-0x3FF) CLOCK(40000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Users;.\Driver
  group Users
    ./Users/: main.c main.h
  group Driver
    ./Driver/: delay.c delay.h timer0.c timer0.h keyInput.c keyInput.h keyConfig.h XPT2046.c XPT2046.h nixieSTC89C52RC.c nixieSTC89C52RC.h
