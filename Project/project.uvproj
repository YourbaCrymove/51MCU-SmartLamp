# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0-0x3FF) CLOCK(40000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Common;..\Core;..\Driver\nixie;..\Driver\xpt2046;..\Driver\key;..\Driver\timer;..\Driver\lightControl
  group Core
    ../Core/: main.c
  group Common
    ../Common/: delay.c
  group Driver
    ../Driver/xpt2046/: xpt2046.c
    ../Driver/key/: key.c
    ../Driver/nixie/: nixie.c
    ../Driver/timer/: timer.c
    ../Driver/lightControl/: lightControl.c
